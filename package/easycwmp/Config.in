## package/easycwmp/Config.in
```kconfig
config PACKAGE_EASYCWMP
    bool "easycwmp"
    default n
    help
      EasyCWMP - TR-069 CPE client
```
